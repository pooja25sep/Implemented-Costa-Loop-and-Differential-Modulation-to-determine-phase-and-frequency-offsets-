options:
  parameters:
    generate_options: qt_gui
    id: costa_loop
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Qpsk
  id: variable
  parameters:
    value: '[-1-1j, -1+1j,1-1j, 1+1j]'
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: freq_slider
  states: {}
- name: freq_slider
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0.4'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '3'
  states: {}
- name: ip_factor
  id: variable
  parameters:
    value: '20'
  states: {}
- name: noise_amp
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '5'
    value: '0'
  states: {}
- name: ntaps
  id: variable
  parameters:
    value: 11*sps
  states: {}
- name: r_alpha
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: symb_rate*sps
  states: {}
- name: samp_rate_iq
  id: variable
  parameters:
    value: samp_rate*ip_factor
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: symb_rate
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: t_alpha
  id: variable
  parameters:
    value: t_alpha_range
  states: {}
- name: t_alpha_range
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.05'
    stop: '1'
    value: '1'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '1e-3'
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    const_points: Qpsk
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_amp
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '500000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate_iq
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 500000+freq_offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate_iq
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 500000+freq_offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate_iq
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_1
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '150'
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\YASH\Desktop\Mtech stuff\placement\projects\final projects\costa loop and DM\pooja\output_costa.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\YASH\Desktop\Mtech stuff\placement\projects\final projects\costa loop and DM\pooja\original_data.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1.414'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1.414'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_2
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_2_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_2_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_pack_k_bits_bb_0_0_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_skiphead_1_0_0
  id: blocks_skiphead
  parameters:
    num_items: '3'
    type: byte
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: thresh
    init: '0'
    low: '-thresh'
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: thresh
    init: '0'
    low: '-thresh'
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: symb_rate
    sensitivity: '-5'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: Qpsk
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: variable_constellation_0
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: sps
    taps: '1'
    type: ccf
  states: {}
- name: iir_filter_xxx_0
  id: iir_filter_xxx
  parameters:
    fbtaps: '[1,0.99]'
    fftaps: '[0.01]'
    type: ffd
  states: {}
- name: iir_filter_xxx_0_0
  id: iir_filter_xxx
  parameters:
    fbtaps: '[-1,1]'
    fftaps: '[1.0001,-1]'
    type: ffd
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: '1'
    type: ccc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '40000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate_iq
    type: fir_filter_fff
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '40000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate_iq
    type: fir_filter_fff
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: symb_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@0
    plotfreq: 'False'
    plottime: 'False'
    plotwaterfall: 'False'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate_iq
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@1
    plotconst: 'False'
    plottime: 'False'
    plotwaterfall: 'False'
    type: float
  states: {}
- name: qtgui_sink_x_0_1
  id: qtgui_sink_x
  parameters:
    bw: symb_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@2
    plotfreq: 'False'
    plottime: 'False'
    plotwaterfall: 'False'
    type: complex
  states: {}
- name: qtgui_sink_x_0_1_0
  id: qtgui_sink_x
  parameters:
    bw: symb_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@4
    plotfreq: 'False'
    plottime: 'False'
    plotwaterfall: 'False'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: tab@3
    size: '1024'
    srate: symb_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: ip_factor
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '1'
    taps: firdes.root_raised_cosine(gain,samp_rate,symb_rate,t_alpha,ntaps)
    type: ccf
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '1'
    taps: firdes.root_raised_cosine(gain,samp_rate,symb_rate,r_alpha,ntaps)
    type: ccf
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: ip_factor
    interp: '1'
    type: ccc
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: symbol vs chunk
    label1: transmitted_signal
    label2: match_filtered_sps_1
    label3: saw_tooth_wave
    label4: final_output
    num_tabs: '5'
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: a
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: b
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: a
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: b
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:50001
    timeout: '100'
    type: float
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:50001
    timeout: '100'
    type: float
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_1, '1']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_1_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_add_const_vxx_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_add_const_vxx_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_1, '0']
- [blocks_complex_to_imag_0, '0', blocks_multiply_xx_2, '1']
- [blocks_complex_to_imag_0, '0', blocks_threshold_ff_0_0, '0']
- [blocks_complex_to_real_0, '0', blocks_add_xx_0, '0']
- [blocks_complex_to_real_1, '0', blocks_multiply_xx_2_0, '1']
- [blocks_complex_to_real_1, '0', blocks_threshold_ff_0, '0']
- [blocks_delay_0, '0', iir_filter_xxx_0_0, '0']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_float_to_complex_0, '0', rational_resampler_xxx_1, '0']
- [blocks_float_to_complex_1_0, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_xx_2, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_multiply_xx_2_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_float_to_complex_1_0, '1']
- [blocks_multiply_const_vxx_0_1, '0', blocks_float_to_complex_1_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_float_to_complex_0, '1']
- [blocks_multiply_const_vxx_2, '0', zeromq_push_sink_0, '0']
- [blocks_multiply_const_vxx_2_0, '0', blocks_vco_c_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_complex_to_real_0, '0']
- [blocks_multiply_xx_1, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_1_0, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_xx_2, '0', blocks_sub_xx_0, '0']
- [blocks_multiply_xx_2_0, '0', blocks_sub_xx_0, '1']
- [blocks_multiply_xx_2_1, '0', blocks_complex_to_imag_0, '0']
- [blocks_multiply_xx_2_1, '0', blocks_complex_to_real_1, '0']
- [blocks_multiply_xx_2_1, '0', qtgui_sink_x_0_1_0, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_pack_k_bits_bb_0_0_0_0, '0', blocks_file_sink_0, '0']
- [blocks_pack_k_bits_bb_0_0_0_0, '0', blocks_null_sink_0, '0']
- [blocks_skiphead_1_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [blocks_sub_xx_0, '0', iir_filter_xxx_0, '0']
- [blocks_threshold_ff_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_threshold_ff_0_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_pack_k_bits_bb_0_0_0_0, '0']
- [blocks_vco_c_0, '0', blocks_multiply_xx_2_1, '1']
- [blocks_vco_c_0, '0', blocks_null_sink_0_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', interp_fir_filter_xxx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', qtgui_sink_x_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_skiphead_1_0_0, '0']
- [fir_filter_xxx_0_0, '0', qtgui_sink_x_0_1, '0']
- [fir_filter_xxx_0_0, '0', virtual_sink_2, '0']
- [iir_filter_xxx_0, '0', blocks_multiply_const_vxx_2, '0']
- [iir_filter_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [iir_filter_xxx_0_0, '0', blocks_multiply_const_vxx_2_0, '0']
- [interp_fir_filter_xxx_0, '0', rational_resampler_xxx_0_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_const_vxx_1, '0']
- [low_pass_filter_0_0, '0', blocks_float_to_complex_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0_0, '0']
- [rational_resampler_xxx_0_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0_0_0, '0', fir_filter_xxx_0_0, '0']
- [rational_resampler_xxx_1, '0', rational_resampler_xxx_0_0_0, '0']
- [virtual_source_1, '0', blocks_multiply_xx_1, '0']
- [virtual_source_1, '0', blocks_multiply_xx_1_0, '1']
- [virtual_source_2, '0', blocks_multiply_xx_2_1, '0']
- [zeromq_pull_source_0, '0', blocks_delay_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
