options:
  parameters:
    generate_options: qt_gui
    id: bpsk_dm
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Bpsk
  id: variable
  parameters:
    value: '[-1,1]'
  states: {}
- name: Qpsk
  id: variable
  parameters:
    value: '[-1-1j, -1+1j,1-1j, 1+1j]'
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: freq_slider
  states: {}
- name: freq_slider
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '3'
  states: {}
- name: ip_factor
  id: variable
  parameters:
    value: '20'
  states: {}
- name: noise_amp
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '5'
    value: '0'
  states: {}
- name: ntaps
  id: variable
  parameters:
    value: 11*sps
  states: {}
- name: phase_slider
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0'
  states: {}
- name: r_alpha
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: symb_rate*sps
  states: {}
- name: samp_rate_iq
  id: variable
  parameters:
    value: samp_rate*ip_factor
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: symb_rate
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: t_alpha
  id: variable
  parameters:
    value: t_alpha_range
  states: {}
- name: t_alpha_range
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.05'
    stop: '1'
    value: '1'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '1e-3'
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    const_points: Bpsk
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '2'
    sym_map: '[0,1]'
    type: calcdist
  states: {}
- name: variable_constellation_qpsk
  id: variable_constellation
  parameters:
    const_points: Qpsk
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0,1,2,3]'
    type: calcdist
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_amp
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '500000'
    offset: '0'
    phase: phase_slider
    samp_rate: samp_rate_iq
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 500000+freq_offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate_iq
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\YASH\Desktop\Mtech stuff\placement\projects\final projects\costa loop and DM\pooja\output_bpsk_dm.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\YASH\Desktop\Mtech stuff\placement\projects\final projects\costa loop and DM\pooja\original_data.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_complex_1_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0_0_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_skiphead_1_0_0
  id: blocks_skiphead
  parameters:
    num_items: '7'
    type: byte
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: thresh
    init: '0'
    low: '-thresh'
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: Bpsk
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: variable_constellation_0
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: sps
    taps: '1'
    type: fff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: '1'
    type: fff
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '40000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate_iq
    type: fir_filter_fff
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: symb_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@0
    plotfreq: 'False'
    plottime: 'False'
    plotwaterfall: 'False'
    type: float
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate_iq
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@1
    plotconst: 'False'
    plottime: 'False'
    plotwaterfall: 'False'
    type: float
  states: {}
- name: qtgui_sink_x_0_1_0
  id: qtgui_sink_x
  parameters:
    bw: symb_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@4
    plotfreq: 'False'
    plottime: 'False'
    plotwaterfall: 'False'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: ip_factor
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '1'
    taps: firdes.root_raised_cosine(gain,samp_rate,symb_rate,t_alpha,ntaps)
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '1'
    taps: firdes.root_raised_cosine(gain,samp_rate,symb_rate,r_alpha,ntaps)
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: ip_factor
    interp: '1'
    type: fff
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: symbol vs chunk
    label1: transmitted_signal
    label2: match_filtered_sps_1
    label3: saw_tooth_wave
    label4: final_output
    label5: costas_loop
    num_tabs: '6'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: b
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: a
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: b
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: a
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_1_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_xx_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_1, '0']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_float_to_complex_1_0, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_complex_1_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_1_0, '0', low_pass_filter_0_0, '0']
- [blocks_pack_k_bits_bb_0_0_0_0, '0', blocks_file_sink_0, '0']
- [blocks_pack_k_bits_bb_0_0_0_0, '0', blocks_null_sink_0, '0']
- [blocks_skiphead_1_0_0, '0', digital_diff_decoder_bb_0, '0']
- [blocks_threshold_ff_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_diff_encoder_bb_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', interp_fir_filter_xxx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', qtgui_sink_x_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_skiphead_1_0_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_pack_k_bits_bb_0_0_0_0, '0']
- [digital_diff_encoder_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [fir_filter_xxx_0_0, '0', virtual_sink_0, '0']
- [interp_fir_filter_xxx_0, '0', rational_resampler_xxx_0_0, '0']
- [low_pass_filter_0_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0_0, '0']
- [rational_resampler_xxx_0_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0_0_0, '0', fir_filter_xxx_0_0, '0']
- [rational_resampler_xxx_1, '0', rational_resampler_xxx_0_0_0, '0']
- [virtual_source_0, '0', blocks_threshold_ff_0, '0']
- [virtual_source_0, '0', qtgui_sink_x_0_1_0, '0']
- [virtual_source_1, '0', blocks_multiply_xx_1_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
